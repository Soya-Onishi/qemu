## hw/rl78/Kconfig
```kconfig
config RL78_MCU
    bool
    select  RL78_SAU

config RL78_GDBSIM
    bool
    default y
    select RL78_MCU
```
